# IAR project stm8s903.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: user/; user/src/; user/inc/; addon/; addon/src/; addon/inc/; sys/; sys/inc/; sys/src/; lib/; lib/src/; lib/inc/
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: CH79_A0.hex
  ILINK.IlinkOutputFile: stm8s003F3.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: stm8s903.out
  group (top)
    sys/src/: stm8s_exti.c
  group Document
    Document/: 程序说明.txt
  group sys
    sys/src/: Afe_bq769x0_user.c bsp_printf.c data_def.c main.c soc.c stm8s_awu.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_it.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c user.c
    sys/: sysctrl.h type.h
